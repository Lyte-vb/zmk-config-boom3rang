## boards/shields/Kconfig.defconfig
```kconfig
if ZMK_SHIELD_BOOM3RANG
			
config ZMK_KEYBOARD_NAME
	default "boom3rang"

endif
```
